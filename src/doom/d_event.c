//
// Copyright(C) 1993-1996 Id Software, Inc.
// Copyright(C) 2005-2014 Simon Howard
//
// This program is free software; you can redistribute it and/or
// modify it under the terms of the GNU General Public License
// as published by the Free Software Foundation; either version 2
// of the License, or (at your option) any later version.
//
// This program is distributed in the hope that it will be useful,
// but WITHOUT ANY WARRANTY; without even the implied warranty of
// MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
// GNU General Public License for more details.
//
//
// DESCRIPTION: Event handling.
//
// Events are asynchronous inputs generally generated by the game user.
// Events can be discarded if no responder claims them
//

#include <stdlib.h>
#include "d_event.h"
#ifdef ESP32
#include "esp32mem.h"
#include "i_system.h"
#endif

#define MAXEVENTS 64

#ifdef ESP32
static event_t *events;
#else
static event_t events[MAXEVENTS];
#endif
static int eventhead;
static int eventtail;

#ifdef ESP32
static void doom_esp32_alloc_events(void)
{
    if (events == NULL)
    {
        events = DOOM_PSRAM_CALLOC(MAXEVENTS, sizeof(*events));
        if (events == NULL)
        {
            I_Error("events: PSRAM alloc failed");
        }
    }
}
#endif

//
// D_PostEvent
// Called by the I/O functions when input is detected
//
void D_PostEvent (event_t* ev)
{
#ifdef ESP32
    doom_esp32_alloc_events();
#endif
    events[eventhead] = *ev;
    eventhead = (eventhead + 1) % MAXEVENTS;
}

// Read an event from the queue.

event_t *D_PopEvent(void)
{
    event_t *result;

#ifdef ESP32
    doom_esp32_alloc_events();
#endif

    // No more events waiting.

    if (eventtail == eventhead)
    {
        return NULL;
    }
    
    result = &events[eventtail];

    // Advance to the next event in the queue.

    eventtail = (eventtail + 1) % MAXEVENTS;

    return result;
}


